# IAR project Indicator_Pallada.ewp, settings and files
configuration Indicator_Pallada Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../; ../Inc; ../src; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/; ../Library/; ../Library/u8glib-master/csrc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Indicator_Pallada Configuration.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Display
    ../Src/Display/: Display_task.cpp Display_task.hpp
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
  group Application/GSM
    ../Src/GSMTask/: GSMTask.cpp GSMTask.hpp
  group Application/Radio
    ../Src/Radio/: Radio_task.cpp Radio_task.hpp
  group Application/SystemTask
    ../Src/SystemTask/: SystemTask.c SystemTask.h
  group Application/User
    ../Src/: freertos.c main.c stm32f1xx_it.c
    ../Inc/: FreeRTOSConfig.h
  group Drivers
    ../Src/: stm32f1xx_hal_msp.c
  group Drivers/Board
    ../Drivers/Board/: Board.cpp Board.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/Keyboard
    ../Drivers/Keyboard/: keyboard.cpp keyboard.h
  group Drivers/LCD
    ../Drivers/LCD/: m2esarmu8g.c u8g_arm.c u8g_arm.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_usb.c
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_wwdg.h
  group Drivers/GSM
    ../Library/GSMSHIELD/: SIM800HWDriver.cpp SIM800HWDriver.h
  group Drivers/USB
    ../Drivers/USB/: usb_device.c usb_device.h usbd_cdc_if.c usbd_cdc_if.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h
  group Library/CC110L
    ../Library/CC110L/: cc110L.c cc110L.h
  group Library/MT2tklib
    ../Library/M2tklib/: M2tk.cpp M2tk.h
  group Library/MT2tklib/utility
    ../Library/M2tklib/utility/: m2.c m2.h m2align.c m2dfs.c m2draw.c m2eh2bd.c m2eh2bs.c m2eh4bd.c m2eh4bs.c m2eh6bs.c m2ehts.c m2el2lmenu.c m2elalign.c m2elbutton.c m2elbuttonptr.c m2elcombo.c m2elcombofn.c m2elcomboptr.c m2elfnfmt.c m2elhide.c m2elinfo.c m2ellabel.c m2ellabelfn.c m2ellabelp.c m2ellabelptr.c m2ellistbase.c m2ellistcalc.c m2ellistgrid.c m2ellisth.c m2ellistv.c m2ellistxy.c m2elradio.c m2elroot.c m2els8base.c m2els8num.c m2elsb.c m2elsetval.c m2elslbase.c m2elspace.c m2elstr.c m2elstrlist.c m2elstrptr.c m2elstrup.c m2elsubutl.c m2eltext.c m2eltoggle.c m2eltsk.c m2elu32.c m2elu8base.c m2elu8hs.c m2elu8num.c m2elxbm.c m2fnarg.c m2gfx.c m2gfxutl.c m2ghdummy.c m2ghu8g.h m2ghu8gbf.c m2ghu8gbfs.c m2ghu8gcffs.c m2ghu8gfb.c m2ghu8gffs.c m2ghu8gicon.c m2ghu8gutl.c m2key.c m2msg.c m2navdatadn.c m2navdataup.c m2navfirst.c m2navinit.c m2navlast.c m2navnext.c m2navprev.c m2navroot.c m2navupdn.c m2navutl.c m2null.c m2obj.c m2opt.c m2pin.c m2qk.c m2rom.c m2usrnext.c m2usrprev.c m2usrupdn.c m2utl.h m2utls8d.c m2utlstrdat.c m2utlu8d.c mas.c mas.h mas_pff.c mas_sim.c pff.c pff.h pff_diskio.c pff_diskio.h pff_integer.h pff_io.h
  group Library/PrintScan
    ../Library/PrintScan/: Parser.cpp Parser.hpp Print.cpp Print.hpp
  group Library/Serial
    ../Library/Serial/: Serial.c Serial.h
  group Library/SIM800
    ../Library/GSMSHIELD/: call.cpp call.h gps.cpp gps.h GSM.cpp GSM.h inetGSM.cpp inetGSM.h SIM800.cpp SIM800.h sms.cpp sms.h
  group Library/U8GLib-Master/cppsrc
    ../Library/u8glib-master/cppsrc/: U8glib.cpp u8glib.h
  group Library/U8GLib-Master/csrc
    ../Library/u8glib-master/csrc/: chessengine.c u8g.h u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_i2c.c u8g_com_io.c u8g_com_linux_ssd_i2c.c u8g_com_msp430_hw_spi.c u8g_com_null.c u8g_com_psoc5_ssd_hw_parallel.c u8g_com_raspberrypi_hw_spi.c u8g_com_raspberrypi_ssd_i2c.c u8g_com_std_sw_spi.c u8g_cursor.c u8g_delay.c u8g_dev_st7565_64128n.c u8g_ellipse.c u8g_font.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pbxh16.c u8g_pbxh24.c u8g_polygon.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u16toa.c u8g_u8toa.c u8g_virtual_screen.c
  group Library/U8GLib-Master/fntsrc
    ../Library/u8glib-master/fntsrc/: a_LCDNova.c a_LCDNova_digit21.c BulgariaFantastica_Cyr.c GOSTtypeB.c my_Bulgaria_Fantastica_Cyr.c my_small_font_Cyr6.c my_small_font_Cyr7.c smallFonts_cyr.c u8g_font_04b_03.c u8g_font_04b_03b.c u8g_font_04b_03bn.c u8g_font_04b_03br.c u8g_font_04b_03n.c u8g_font_04b_03r.c u8g_font_04b_24.c u8g_font_04b_24n.c u8g_font_04b_24r.c u8g_font_10x20.c u8g_font_10x20_67_75.c u8g_font_10x20_75r.c u8g_font_10x20_78_79.c u8g_font_10x20r.c u8g_font_4x6.c u8g_font_4x6r.c u8g_font_5x7.c u8g_font_5x7r.c u8g_font_5x8.c u8g_font_5x8r.c u8g_font_6x10.c u8g_font_6x10r.c u8g_font_6x12.c u8g_font_6x12_67_75.c u8g_font_6x12_75r.c u8g_font_6x12_78_79.c u8g_font_6x12r.c u8g_font_6x13.c u8g_font_6x13_67_75.c u8g_font_6x13_75r.c u8g_font_6x13_78_79.c u8g_font_6x13B.c u8g_font_6x13Br.c u8g_font_6x13O.c u8g_font_6x13Or.c u8g_font_6x13r.c u8g_font_7x13.c u8g_font_7x13_67_75.c u8g_font_7x13_75r.c u8g_font_7x13B.c u8g_font_7x13Br.c u8g_font_7x13O.c u8g_font_7x13Or.c u8g_font_7x13r.c u8g_font_7x14.c u8g_font_7x14B.c u8g_font_7x14Br.c u8g_font_7x14r.c u8g_font_8x13.c u8g_font_8x13_67_75.c u8g_font_8x13_75r.c u8g_font_8x13B.c u8g_font_8x13Br.c u8g_font_8x13O.c u8g_font_8x13Or.c u8g_font_8x13r.c u8g_font_9x15.c u8g_font_9x15_67_75.c u8g_font_9x15_75r.c u8g_font_9x15_78_79.c u8g_font_9x15B.c u8g_font_9x15Br.c u8g_font_9x15r.c u8g_font_9x18.c u8g_font_9x18_67_75.c u8g_font_9x18_75r.c u8g_font_9x18_78_79.c u8g_font_9x18B.c u8g_font_9x18Br.c u8g_font_9x18r.c u8g_font_baby.c u8g_font_babyn.c u8g_font_babyr.c u8g_font_blipfest_07.c u8g_font_blipfest_07n.c u8g_font_blipfest_07r.c u8g_font_chikita.c u8g_font_chikitan.c u8g_font_chikitar.c u8g_font_courb08.c u8g_font_courb08r.c u8g_font_courb10.c u8g_font_courb10r.c u8g_font_courb12.c u8g_font_courb12r.c u8g_font_courb14.c u8g_font_courb14r.c u8g_font_courb18.c u8g_font_courb18r.c u8g_font_courb24.c u8g_font_courb24r.c u8g_font_courb4n.c u8g_font_courr08.c u8g_font_courr08r.c u8g_font_courr10.c u8g_font_courr10r.c u8g_font_courr12.c u8g_font_courr12r.c u8g_font_courr14.c u8g_font_courr14r.c u8g_font_courr18.c u8g_font_courr18r.c u8g_font_courr24.c u8g_font_courr24n.c u8g_font_courr24r.c u8g_font_cu12.c u8g_font_cu12_67_75.c u8g_font_cu12_75r.c u8g_font_cursor.c u8g_font_cursorr.c u8g_font_fixed_v0.c u8g_font_fixed_v0n.c u8g_font_fixed_v0r.c u8g_font_freedoomr10r.c u8g_font_freedoomr25n.c u8g_font_fub11.c u8g_font_fub11n.c u8g_font_fub11r.c u8g_font_fub14.c u8g_font_fub14n.c u8g_font_fub14r.c u8g_font_fub17.c u8g_font_fub17n.c u8g_font_fub17r.c u8g_font_fub20.c u8g_font_fub20n.c u8g_font_fub20r.c u8g_font_fub25.c u8g_font_fub25n.c u8g_font_fub25r.c u8g_font_fub30.c u8g_font_fub30n.c u8g_font_fub30r.c u8g_font_fub35n.c u8g_font_fub42n.c u8g_font_fub49n.c u8g_font_fur11.c u8g_font_fur11n.c u8g_font_fur11r.c u8g_font_fur14.c u8g_font_fur14n.c u8g_font_fur14r.c u8g_font_fur17.c u8g_font_fur17n.c u8g_font_fur17r.c u8g_font_fur20.c u8g_font_fur20n.c u8g_font_fur20r.c u8g_font_fur25.c u8g_font_fur25n.c u8g_font_fur25r.c u8g_font_fur30.c u8g_font_fur30n.c u8g_font_fur30r.c u8g_font_fur35n.c u8g_font_fur42n.c u8g_font_fur49n.c u8g_font_gdb11.c u8g_font_gdb11n.c u8g_font_gdb11r.c u8g_font_gdb12.c u8g_font_gdb12n.c u8g_font_gdb12r.c u8g_font_gdb14.c u8g_font_gdb14n.c u8g_font_gdb14r.c u8g_font_gdb17.c u8g_font_gdb17n.c u8g_font_gdb17r.c u8g_font_gdb20.c u8g_font_gdb20n.c u8g_font_gdb20r.c u8g_font_gdb25.c u8g_font_gdb25n.c u8g_font_gdb25r.c u8g_font_gdb30.c u8g_font_gdb30n.c u8g_font_gdb30r.c u8g_font_gdr10.c u8g_font_gdr10n.c u8g_font_gdr10r.c u8g_font_gdr11.c u8g_font_gdr11n.c u8g_font_gdr11r.c u8g_font_gdr12.c u8g_font_gdr12n.c u8g_font_gdr12r.c u8g_font_gdr14.c u8g_font_gdr14n.c u8g_font_gdr14r.c u8g_font_gdr17.c u8g_font_gdr17n.c u8g_font_gdr17r.c u8g_font_gdr20.c u8g_font_gdr20n.c u8g_font_gdr20r.c u8g_font_gdr25.c u8g_font_gdr25n.c u8g_font_gdr25r.c u8g_font_gdr30.c u8g_font_gdr30n.c u8g_font_gdr30r.c u8g_font_gdr9.c u8g_font_gdr9n.c u8g_font_gdr9r.c u8g_font_helvb08.c u8g_font_helvb08n.c u8g_font_helvb08r.c u8g_font_helvb10.c u8g_font_helvb10n.c u8g_font_helvb10r.c u8g_font_helvb12.c u8g_font_helvb12n.c u8g_font_helvb12r.c u8g_font_helvb14.c u8g_font_helvb14n.c u8g_font_helvb14r.c u8g_font_helvb18.c u8g_font_helvb18n.c u8g_font_helvb18r.c u8g_font_helvb24.c u8g_font_helvb24n.c u8g_font_helvb24r.c u8g_font_helvr08.c u8g_font_helvr08r.c u8g_font_helvr10.c u8g_font_helvr10r.c u8g_font_helvr12.c u8g_font_helvr12r.c u8g_font_helvr14.c u8g_font_helvr14r.c u8g_font_helvr18.c u8g_font_helvr18r.c u8g_font_helvr24.c u8g_font_helvr24n.c u8g_font_helvr24r.c u8g_font_lucasfont_alternate.c u8g_font_lucasfont_alternaten.c u8g_font_lucasfont_alternater.c u8g_font_m2icon_5.c u8g_font_m2icon_7.c u8g_font_m2icon_9.c u8g_font_micro.c u8g_font_ncenb08.c u8g_font_ncenb08r.c u8g_font_ncenb10.c u8g_font_ncenb10r.c u8g_font_ncenb12.c u8g_font_ncenb12r.c u8g_font_ncenb14.c u8g_font_ncenb14r.c u8g_font_ncenb18.c u8g_font_ncenb18r.c u8g_font_ncenb24.c u8g_font_ncenb24n.c u8g_font_ncenb24r.c u8g_font_ncenr08.c u8g_font_ncenr08r.c u8g_font_ncenr10.c u8g_font_ncenr10r.c u8g_font_ncenr12.c u8g_font_ncenr12r.c u8g_font_ncenr14.c u8g_font_ncenr14r.c u8g_font_ncenr18.c u8g_font_ncenr18r.c u8g_font_ncenr24.c u8g_font_ncenr24n.c u8g_font_ncenr24r.c u8g_font_orgv01.c u8g_font_orgv01n.c u8g_font_orgv01r.c u8g_font_osb18.c u8g_font_osb18n.c u8g_font_osb18r.c u8g_font_osb21.c u8g_font_osb21n.c u8g_font_osb21r.c u8g_font_osb26.c u8g_font_osb26n.c u8g_font_osb26r.c u8g_font_osb29.c u8g_font_osb29n.c u8g_font_osb29r.c u8g_font_osb35.c u8g_font_osb35n.c u8g_font_osb35r.c u8g_font_osr18.c u8g_font_osr18n.c u8g_font_osr18r.c u8g_font_osr21.c u8g_font_osr21n.c u8g_font_osr21r.c u8g_font_osr26.c u8g_font_osr26n.c u8g_font_osr26r.c u8g_font_osr29.c u8g_font_osr29n.c u8g_font_osr29r.c u8g_font_osr35.c u8g_font_osr35n.c u8g_font_osr35r.c u8g_font_p01type.c u8g_font_p01typen.c u8g_font_p01typer.c u8g_font_pixelle_micro.c u8g_font_pixelle_micron.c u8g_font_pixelle_micror.c u8g_font_profont10.c u8g_font_profont10r.c u8g_font_profont11.c u8g_font_profont11r.c u8g_font_profont12.c u8g_font_profont12r.c u8g_font_profont15.c u8g_font_profont15r.c u8g_font_profont17.c u8g_font_profont17r.c u8g_font_profont22.c u8g_font_profont22r.c u8g_font_profont29.c u8g_font_profont29r.c u8g_font_robot_de_niro.c u8g_font_robot_de_niron.c u8g_font_robot_de_niror.c u8g_font_symb08.c u8g_font_symb08r.c u8g_font_symb10.c u8g_font_symb10r.c u8g_font_symb12.c u8g_font_symb12r.c u8g_font_symb14.c u8g_font_symb14r.c u8g_font_symb18.c u8g_font_symb18r.c u8g_font_symb24.c u8g_font_symb24r.c u8g_font_timb08.c u8g_font_timb08r.c u8g_font_timb10.c u8g_font_timb10r.c u8g_font_timb12.c u8g_font_timb12r.c u8g_font_timb14.c u8g_font_timb14r.c u8g_font_timb18.c u8g_font_timb18r.c u8g_font_timb24.c u8g_font_timb24n.c u8g_font_timb24r.c u8g_font_timr08.c u8g_font_timr08r.c u8g_font_timr10.c u8g_font_timr10r.c u8g_font_timr12.c u8g_font_timr12r.c u8g_font_timr14.c u8g_font_timr14r.c u8g_font_timr18.c u8g_font_timr18r.c u8g_font_timr24.c u8g_font_timr24n.c u8g_font_timr24r.c u8g_font_tpss.c u8g_font_tpssb.c u8g_font_tpssbn.c u8g_font_tpssbr.c u8g_font_tpssn.c u8g_font_tpssr.c u8g_font_trixel_square.c u8g_font_trixel_squaren.c u8g_font_trixel_squarer.c u8g_font_u8glib_4.c u8g_font_u8glib_4r.c u8g_font_unifont.c u8g_font_unifont_0_8.c u8g_font_unifont_12_13.c u8g_font_unifont_18_19.c u8g_font_unifont_2_3.c u8g_font_unifont_4_5.c u8g_font_unifont_67_75.c u8g_font_unifont_72_73.c u8g_font_unifont_75r.c u8g_font_unifont_76.c u8g_font_unifont_77.c u8g_font_unifont_78_79.c u8g_font_unifont_86.c u8g_font_unifont_8_9.c u8g_font_unifontr.c
  group Library/Utils
    ../Library/Utils/: Utils.c Utils.h
  group Library/wMBus
    ../Library/WMBus/: WMBus.c WMBus.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
